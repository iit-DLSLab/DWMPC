Commit message: fix aliengo urdf for new adam version

File: urdf/aliengo.urdf (robot description, URDF)
Before this commit: robot aliengo, 31 links, 30 joints
Joints:
- removed joint floating_base
